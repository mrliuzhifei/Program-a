# Keil uVision project Tem_Humi_CO2.uvproj, settings and files
target UserCode (MCS-51)
  device: ML54SD1AE Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0xFFFF)  XRAM(0 - 0xFFF) CLOCK(24000000)
  output: Temp_Humi_CO2 +hex
  c flags: Optimize=7 SizeSpeed=1
  c include: ..\..\..\UserCode\Device\Include;..\..\..\UserCode\StdDriver\inc;..\..\..\UserCode\User\ins;..\..\..\UserCode\StdDriver\src;..\..\..\UserCode\StdDriver\lib
  group Source Group 1
    ../: main.c.c
  group Library
    ../../../UserCode/StdDriver/src/: uart2.c common.c adc.c gpio.c i2c.c uart3.c uart.c pwm0.c pwm123.c eeprom.c lcd.c sys.c
  group Startup
    ../../../UserCode/Startup/KEIL/: STARTUP.A51
  group User
    ../../../UserCode/User/src/: ADC_USER.c CO2.c CRC8_NRSC5.C EEPROM_USER.c KEY.c LCD_User.c LED.c SHTC3.c Timer0.c UART1_USER.C UART2_USER.C UART3_USER.C WDT.c WIFI.c CRC16.C BC3602.c BC3602_Gateway.c BC3602_SPI.C
